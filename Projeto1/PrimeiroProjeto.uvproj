# Keil uVision project PrimeiroProjeto.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: PrimeiroProjeto
  c flags: Optimize=8 SizeSpeed=1
  group Codigo
    ./: Main.c
