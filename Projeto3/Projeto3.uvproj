# Keil uVision project Projeto3.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: Projeto3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c
